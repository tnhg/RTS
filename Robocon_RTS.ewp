# IAR project Robocon_RTS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F427II ST STM32F427II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F427_437xx; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: APP\inc; ST\inc; ST\System; uCOSIII\uC_CPU\Cfg; uCOSIII\uC_CPU\Ports\IAR; uCOSIII\uC_CPU\Source; uCOSIII\uC_LIB\Cfg; uCOSIII\uC_LIB\Ports; uCOSIII\uC_LIB\Source; uCOSIII\uC_OS3\Cfg; uCOSIII\uC_OS3\Ports\IAR; uCOSIII\uC_OS3\Source; ST\System
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Robocon_RTS.srec
  ILINK.IlinkOutputFile: Robocon_RTS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    APP/src/: app.c bsp.c led.c tim.c usart.c
  group ST
    ST/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group ST/System
    ST/System/: startup_stm32f427_437xx.s stm32f4xx_it.c system_stm32f4xx.c
  group UC/OSIII/uC-CPU
    uCOSIII/uC_CPU/Ports/IAR/: cpu_a.asm
    uCOSIII/uC_CPU/Ports/: cpu_c.c
    uCOSIII/uC_CPU/Source/: cpu_core.c
  group UC/OSIII/uC-LIB
    uCOSIII/uC_LIB/Source/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group UC/OSIII/uC-OS3
    uCOSIII/uC_OS3/Cfg/: os_app_hooks.c
    uCOSIII/uC_OS3/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    uCOSIII/uC_OS3/Ports/IAR/: os_cpu_a.asm
    uCOSIII/uC_OS3/Ports/: os_cpu_c.c
